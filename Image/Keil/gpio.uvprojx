# Keil uVision project gpio.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: gpio +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c startup.s
  group src
    ./src/: ahb_rw.c print_led.c sh32f0xx_bkp.c sh32f0xx_crc.c sh32f0xx_dbgmcu.c sh32f0xx_dma.c sh32f0xx_exti.c sh32f0xx_gpio.c sh32f0xx_i2c.c sh32f0xx_misc.c sh32f0xx_spi.c sh32f0xx_pwr.c sh32f0xx_rcc.c sh32f0xx_syscfg.c sh32f0xx_tim.c sh32f0xx_usart.c sh32f0xx_wwdg.c system_sh32f0xx.c
